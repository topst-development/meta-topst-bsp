FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-feat-dmabuf-add-flags-for-yuv-color-space-and-range.patch \
"
