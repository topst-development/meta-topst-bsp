PACKAGECONFIG:class-nativesdk:remove = "sdl virglrenderer epoxy"
